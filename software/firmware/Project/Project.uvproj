# Keil uVision project Project.uvproj, settings and files
target STM32F40_41xxx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\Hardware;..\config;..\devo;..\protocol;..\petit_fat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Hardware
    ../Hardware/: delay.c led.c drv_lcd.c
  group STM32F4xx_StdPeriph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s startup_stm32f40_41xxx.s startup_stm32f401xx.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s
  group Config
    ../config/: display.c hardware.c ini.c language.c model.c tx.c
  group devo
    ../devo/: autodimmer.c battery.c buttons.c curves.c datalog.c inputs.c misc.c mixer.c mixer_standard.c music.c remap_channels.c rtc.c telemetry.c timer.c version.c
  group Protocols
    ../protocol/: cflie_nrf24l01.c devo_cyrf6936.c dsm2_cyrf6936.c esky_nrf24l01.c esky150_nrf24l01.c flysky_a7105.c frsky1way_cc2500.c frsky2way_cc2500.c h377_nrf24l01.c hisky_nrf24l01.c hm830_nrf24l01.c hubsan_a7105.c j6pro_cyrf6936.c kn_nrf24l01.c ne260_nrf24l01.c ppmout.c protocol.c skyartec_cc2500.c slt_nrf24l01.c testrf.c usbhid.c v202_nrf24l01.c wk2x01.c yd717_nrf24l01.c
  group petit_fat
    ../petit_fat/: petit_fat.c petit_io.c
